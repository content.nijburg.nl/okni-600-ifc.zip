Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
File name: Project Number
Time: 2022-05-05T14:10:31
Written by: ODA IFC SDK 22.8
Made in: 22.1.21.13 - Exporter 22.1.21.13 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort (5)
Description: Flow
Name | FlowDirection
4 x Port_1275407 | SINK
Port_1275407 | SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_induction unit okni600_LT_sacs:600-1800, NLRS_57_AIR_UN_induction unit okni600_LT_sacs:600-1800:1275407
In: Default
Type - Description: Induction unit for use in modular ceilings, Type OKNI 600; PredefinedType: DIFFUSER; Classification: 57.00 (Uniformat); Material: Sendzimir verzinkt, SACS_Label
Type - Constraints - Default Elevation: 0 mm
Type - Graphics - Offset_Heat: 55 mm; Offset_Koel: 35 mm
Type - Identity Data - Assembly Code: 57.00; Description: Induction unit for use in modular ceilings, Type OKNI 600; Manufacturer: Solid Air Climate Solutions; Model: Solid Air Induction Unit OKNI 600; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 4-05-2022; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.01; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Comments: Do not mirror the model!; Type Name: 600-1800; URL: https://solid-air.nl/producten/solid-air-inductie-units-okni-450-600/
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_induction unit okni600_LT_sacs; SACS_Base_Index: 3
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Type - Pset_ProductRequirements - Category: Air Terminals
Material: RAL9010
Pset_DistributionFlowElementCommon - Reference: 600-1800; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Ceiling raster length: 1800 mm; Ceiling raster width: 600 mm; Minumum length OKNI: 1640 mm; NLRS_M_c01_diameter: 125 mm; NLRS_P_c01_diameter: 15 mm; NLRS_P_c02_diameter: 15 mm; NLRS_P_c03_diameter: 12 mm; NLRS_P_c04_diameter: 12 mm; Requested length: 1795 mm; SACS_Real_Length: 1795 mm; Size: 125ø; Volume: 0.0347578 m3
Identity Data - Mark: 4925; NLRS_C_materiaal_kleur: Ral 9010-55; NLRS_C_model: OKNI 600/1800 B2O4 RO32 O1O 595x1795 RAL9010-55; SACS_Article_Code: NB
Materials and Finishes - SACS_Color: Ral 9010-55; SACS_Face_Color: RAL9010 Perforated; SACS_Flange_Color: RAL9010
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; NLRS_P_c01_drukverlies_statisch: 0 Pa; NLRS_P_c03_drukverlies_statisch: 0 Pa; System Classification: Supply Air,Hydronic Supply,Hydronic Return,Hydronic Supply,Hydronic Return
Mechanical - Flow - Flow: 0 m3/s; NLRS_M_c01_debiet: 0 m3/s; NLRS_P_c01_volumestroom: 0 m3/s; NLRS_P_c03_volumestroom: 0 m3/s
Model Properties - Extravent: no; Flow configuration (1-3): 3; Heat exchanger type (1-3): 3; Nozzle plate type (1-7): 4; Plenum type (1-3): 3; SACS_Color_Ral: yes; SACS_Connection_Side: R (right); SACS_Option_1: Fixed; SACS_Option_2: B2; SACS_Option_3: O (none); SACS_Option_4: 1-sided right; SACS_Standard_Color: yes
Other - Family: NLRS_57_AIR_UN_induction unit okni600_LT_sacs; Family and Type: NLRS_57_AIR_UN_induction unit okni600_LT_sacs: 600-1800; Type: 600-1800; Type Id: 1151454
Phasing - Phase Created: New Construction
